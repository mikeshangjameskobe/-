# Keil uVision project stc89c5x.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: stc89c5x +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\hardware
  asm include: .\hardware
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./hardware/: LCD12864.c LCD12864_Font.c timer.c DA-AD.C I2C.c time_clock.c
